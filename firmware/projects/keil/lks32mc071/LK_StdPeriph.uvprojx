# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 07x Project (6220000::V6.22::ARMCLANG)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BENCH_TEST_CMP_FAIL,M2_P1_DYNAMIC
  c include: .\Include;.\LKS32MC07x_Periph_Driver\Include;.\FreeMaster;.\RTT;..\..\..\board\lks_evb_mvpowpre;..\..\..\tests\bench;..\..\..\motor\commutation;..\..\..\platform\lks32mc071
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group AppFunction
    ./AppFunction/: interrupt.c
    ../../../application/: main.c
    ../../../platform/lks32mc071/: system_startup.c lks_uart.c lks_current_sample.c bench_sixstep_output.c lks560_pwm_defaults.c
    ../../../board/lks_evb_mvpowpre/: board_init.c
    ../../../tests/bench/: test_mcpwm_single.c test_mcpwm_complementary.c test_mcpwm_three_pair.c test_sixstep_logic.c test_gate_driver.c
    ../../../motor/commutation/: sixstep_table.c
    ../../../application/diagnostic/: diagnostic.c protocol_text.c protocol_justfloat.c
    ../../../motor/current/: current_sample.c
    ../../../tests/bench_current/: bench_current.c
  group Periph_Driver
    ./LKS32MC07x_Periph_Driver/Source/: lks32mc07x_exti.c lks32mc07x_gpio.c lks32mc07x_sys.c startup_lks32mc07x.s lks32mc07x_nvr.lib lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_cmp.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32MC07x_flash.c lks32mc07x_hall.c lks32mc07x_mcpwm.c lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_uart.c lks32mc07x_wake.c
  group V02 Protection
    ../../../platform/lks32mc071/: lks_protection.c
    ../../../application/protection/: protection_manager.c
    ../../../tests/bench_cmp_fail/: bench_cmp_fail.c
target Linko 07x Project_ac6 (6160000::V6.16::ARMCLANG)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: as above
  output: LK_StdPeriph +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=7 v6Lto=1 wLevel=3
  c include: .\Include;.\LKS32MC08x_Periph_Driver\Include;.\FreeMaster;.\RTT;.\ac6
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
software components: CMSIS:CORE 5.1.2
